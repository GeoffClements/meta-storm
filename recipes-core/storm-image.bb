include recipes-core/images/core-image-minimal.bb

IMAGE_FEATURES += "storm"